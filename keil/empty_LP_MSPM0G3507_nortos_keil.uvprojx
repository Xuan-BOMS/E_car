# Keil uVision project empty_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_LP_MSPM0G3507_nortos_keil (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\source\third_party\CMSIS\Core\Include;..\..\source;..\gimbal;..\vision;..\time;..\motor;..\HWT101;..\classic;..\OLED;..\State
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: empty.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group gimbal
    ../gimbal/: gimbal.c ZDT_drive.c gimbal.h ZDT_drive.h
  group vision
    ../vision/: vision.c vision.h
  group Time
    ../time/: time.c time.h
  group HWT101
    ../HWT101/: hwt101.c hwt101.h
  group classic
    ../classic/: Encoder.h Gray.h Motor_tb.h motorDK.h Tracking.h Encoder.c Gray.c Motor_tb.c motorDK.c Tracking.c
  group OLED
    ../OLED/: OLED.c OLED.h OLED_Font.h
  group State
    ../State/: Key.h LED.h task.h Key.c LED.c task.c
  group system
    ../system/: max_min.c PID.c PWM.c Timer.c max_min.h PID.h PWM.h Timer.h
